# Keil uVision project CH552.uvproj, settings and files
target ADC (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: adc +hex
  c flags: Optimize=6 SizeSpeed=1
  group CH552
    ./usr/: main.c ADC.c Debug.c
